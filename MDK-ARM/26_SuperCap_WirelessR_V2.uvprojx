# Keil uVision project 26_SuperCap_WirelessR_V2.uvprojx, settings and files
target 26_SuperCap_WirelessR_V2 (6190000::V6.19::ARMCLANG)
  device: STM32G474CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 26_SuperCap_WirelessR_V2 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../User/WirelessR/Inc;../User/SuperCap;../User/SuperCap/bmp;../User/SuperCap/lcd;../User/SuperCap/math_tool;../User/SuperCap/music;../User/SuperCap/task_manager;../User/SuperCap/ws2812;../User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c hrtim.c i2c.c iwdg.c opamp.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group SuperCap
    ../User/SuperCap/lcd/: lcd_comm.cpp
    ../User/SuperCap/math_tool/: my_math.cpp
    ../User/SuperCap/music/: music_player.cpp
    ../User/SuperCap/task_manager/: timer.cpp
    ../User/SuperCap/ws2812/: ws2812.cpp
    ../User/SuperCap/: adc_sample.cpp buck_boost_manager.cpp calibrator_estimator.cpp can_task.cpp control_loop.cpp flash_memory_manager.cpp half_bridge.cpp led_indicator.cpp power_manager.cpp referee_comm.cpp
  group WirelessR
    ../User/WirelessR/Src/: modulator.cpp MP4201.cpp wireless_charge_manager.cpp
  group config
    ../User/: callback.cpp config.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 5.6.0
